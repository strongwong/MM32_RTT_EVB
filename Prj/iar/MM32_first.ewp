# IAR project MM32_first.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32F103x8 MM MM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_IAR; MM32X103; MM32_EVB
  ICCARM.CCIncludePath2: ..\..\App\inc; ..\..\Board\inc; ..\..\Chip\HAL_lib\inc; ..\..\Chip\system\inc; ..\..\RT_Thread\MM32_EVBoard\inc; ..\..\RT_Thread\2.1.1\include; ..\..\RT_Thread\2.1.1\libcpu\arm\cortex-m3
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: MM32_first.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../../App/: main.c study_thread.c
  group Board
    ../../Board/: adc.c can.c datetime.c delay.c i2c.c ir_rx.c ir_tx.c lcd.c lcd_demo.c led_key.c rtc.c spi.c spiflash.c sys.c timers.c uart.c
    ../../RT_Thread/MM32_EVBoard/: board.c
  group HAL_lib
    ../../Chip/HAL_lib/: HAL_adc.c HAL_bkp.c HAL_can.c HAL_comp.c HAL_crc.c HAL_dac.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group RT_thread
    ../../RT_Thread/2.1.1/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c thread.c timer.c
    ../../RT_Thread/2.1.1/libcpu/arm/cortex-m3/: context_iar.S cpuport.c
  group Startup
    ../../Chip/system/iar/: startup_mm32f10x_md.s system_MM32x103.c

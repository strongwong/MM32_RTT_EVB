# Keil uVision project MM32_RTT_EVB.uvprojx, settings and files
target MM32_RTT_EVB (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MM32x103 MindMotion
  pack: MindMotion.MM32x103_DFP.1.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MM32_RTT_EVB +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,MM32X103
  c include: ..\..\Chip\HAL_lib\inc;..\..\Chip\system\inc;..\..\Board\inc;..\..\App\inc;..\..\RT_Thread\2.1.1\include;..\..\RT_Thread\2.1.1\libcpu\arm\cortex-m3;..\..\RT_Thread\MM32_EVBoard\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ../../App/: main.c
  group Board
    ../../Board/: led_key.c adc.c can.c datetime.c delay.c i2c.c ir_rx.c ir_tx.c lcd.c lcd_demo.c rtc.c spi.c spiflash.c sys.c uart.c
  group HAL_lib
    ../../Chip/HAL_lib/: HAL_adc.c HAL_bkp.c HAL_can.c HAL_comp.c HAL_crc.c HAL_dac.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group RT_Thread
    ../../RT_Thread/2.1.1/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
    ../../RT_Thread/2.1.1/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c thread.c timer.c
    ../../RT_Thread/MM32_EVBoard/: board.c
  group Startup
    ../../Chip/system/arm/: system_MM32x103.c startup_MM32x103_md.s
software components: CMSIS:CORE 5.2.0
